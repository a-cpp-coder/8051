# Keil uVision project Assembly_Basics_and_Structure.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Assembly_Basics_and_Structure
  c flags: Optimize=8 SizeSpeed=1
